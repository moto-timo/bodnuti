myclass_helper() {
	echo "${FOO_FEATURES}"
}
